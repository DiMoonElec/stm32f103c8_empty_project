# IAR project test_proj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; CMSIS\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: test_proj.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: flash_stm32f103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group CMSIS
    CMSIS/: core_cm3.h core_cmFunc.h core_cmInstr.h startup_stm32f103xb.s stm32f103xb.h stm32f1xx.h system_stm32f1xx.c system_stm32f1xx.h
